PLATFORM = "talos"
PBT_BUILD_DATE = "260411"

require common.inc

SRC_URI[camxlib.sha256sum]     = "33d6f7056107232b8187e3787613ba33dde0f4efc205a3fa22c1f4a48d32b3cf"
SRC_URI[camx.sha256sum]        = "62a9be143095694ba78e40048b8ea93f4b1d5d00c72aa9285c232130ee4be059"
SRC_URI[chicdk.sha256sum]      = "dc0bf69137d495f4ba4e577a023a1cf121130a97021e9e11b7c106acee69bb3c"
SRC_URI[camxcommon.sha256sum]  = "7c2f75948c218b91f1807f7fa9f34a3d8d8b8b1fcd9e7b7dcdba69399e70a67d"
