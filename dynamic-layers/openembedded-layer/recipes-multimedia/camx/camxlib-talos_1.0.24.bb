PLATFORM = "talos"
PBT_BUILD_DATE = "260515"

require common.inc

SRC_URI[camxlib.sha256sum] = "5ef124eeb3b3eae5ca54651820ba00e004aca6b6aa860fb37d86485ed6489b10"
SRC_URI[camx.sha256sum] = "9bd108e58fc128c76d429c75907c765f5fdf23d1f467c5398b31dd70b10d963e"
SRC_URI[chicdk.sha256sum] = "41f783d9614177bc61c0b8f95f8ff347af348d867fb708c670bc84473cb8dea8"
SRC_URI[camxcommon.sha256sum] = "5b0aefeb4737474f23bf3fa1168ad4da33f528cace047ea82aac79931657a24c"
