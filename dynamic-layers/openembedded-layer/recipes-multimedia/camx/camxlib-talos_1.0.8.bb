PLATFORM = "talos"
PBT_BUILD_DATE = "260416"

require common.inc

SRC_URI[camxlib.sha256sum]     = "79977f594f20a0779cd5e6314edddaacd416416c1a5c22f1399251826b69b7e1"
SRC_URI[camx.sha256sum]        = "280262a4b5c7edbc80dbd131a2fd0270bb83e8ac247eb5bf6abd393a9ae9262e"
SRC_URI[chicdk.sha256sum]      = "74a24691659d5c3248364287dd6b0a735a726bbe78d5d5fbf4f4a5e05371df69"
SRC_URI[camxcommon.sha256sum]  = "9de2262cf02d39279048472ffa780e5da3eae70e0b5c9405cf3c484fd47b3518"
