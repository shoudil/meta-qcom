PLATFORM = "talos"
PBT_BUILD_DATE = "260403"

require common.inc

SRC_URI[camxlib.sha256sum]     = "f99804775c05cd859934270cdc8f43ef8eb27e827bba2df3aec9d0b5700c8a77"
SRC_URI[camx.sha256sum]        = "b6b2dde850ff7d194560d33687615de5417959d154e85036cfa714ae58bc9a2e"
SRC_URI[chicdk.sha256sum]      = "2a0f036e59c035e593d21a4cc7e5b6a3c5a011bfc3e7f0a55d841849443065bc"
SRC_URI[camxcommon.sha256sum]  = "7db3128a0b23c1f001ef799655d6b14f8d4384d78cfa5e3afe8150b9811a3a31"
