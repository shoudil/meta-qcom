PLATFORM = "talos"
PBT_BUILD_DATE = "260608"

require common.inc

SRC_URI[camxlib.sha256sum] = "71b6fa32d429a9811e3ab77b5d68b53184b13f1b0627f2830d2fe876524f1844"
SRC_URI[camx.sha256sum] = "bfaf94dfc0efb09379d137d8fd50942ef4ac57f309e0d394d18a0e96c5d78420"
SRC_URI[chicdk.sha256sum] = "157620217e819a84b04c8181e0b8b7e8ea580fd10f84dd6fe91eb8b5a89059e2"
SRC_URI[camxcommon.sha256sum] = "80a9d45aa4008aadde7b8e49e6f5523eb60d87c3fd14c2accd85ea9239bcac98"
