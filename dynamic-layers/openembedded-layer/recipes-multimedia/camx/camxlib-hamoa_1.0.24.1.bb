PLATFORM = "hamoa"
PBT_BUILD_DATE = "260519"

require common.inc

SRC_URI[camxlib.sha256sum] = "28ee162ab5873f70a18bf4349b4b6e489cd1daea0b206ed6c205ad3ef70de6f3"
SRC_URI[camx.sha256sum] = "9fa2cb9365f8f0258a272e9e57e73ba27285d4cc43ddc1ff4182f69aedbd422d"
SRC_URI[chicdk.sha256sum] = "3b89bda5fe9dd846b02cf50e9c8d2d21372857e47465fa1925b8e9c038e5cbd2"
SRC_URI[camxcommon.sha256sum] = "6333a910f37a7195bd31efcb1b2978cb2186e655a13f655a96a3d11c6c961553"
