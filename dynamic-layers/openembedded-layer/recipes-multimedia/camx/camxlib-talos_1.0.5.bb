PLATFORM = "talos"
PBT_BUILD_DATE = "260324"

require common.inc

SRC_URI[camxlib.sha256sum]     = "541115dd3354948ca86d60011074c2765716b3f6484c3afb1426a9cbdae7db12"
SRC_URI[camx.sha256sum]        = "9067647e57bc9ace9ff91bcb6748e41249ab1c5df3d1a8ac508aca0726fec093"
SRC_URI[chicdk.sha256sum]      = "cb170ac85267314b7a889d1869959376dfc4b0a245abd6b45792f1e8c95ba4b6"
SRC_URI[camxcommon.sha256sum]  = "486b88dda268a518349e30f9d63e81387daff31f9d0bb2dfb5d7b6f7adb4a847"
