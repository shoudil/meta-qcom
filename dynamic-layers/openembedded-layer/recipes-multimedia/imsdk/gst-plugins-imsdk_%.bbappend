PACKAGECONFIG:append = " ml messaging qmmfsrc redissink"
