PACKAGECONFIG:append = " camera-base qmmfsrc"
