PACKAGECONFIG:append = " ml messaging python-apps redissink"
