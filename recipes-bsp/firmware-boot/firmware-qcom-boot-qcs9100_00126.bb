require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "6bcc47460e2127c6bf1ebda1726e87659820dadeceb68f15c52aed80086b64a2"
