require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "00213d5f0c6325aaa25dbb67834285ccdeee9e15c4f76e12c66cf37cf26aaafa"
