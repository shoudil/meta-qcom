require firmware-qcom-boot-iq-x6141.inc

SRC_URI[bootbinaries.sha256sum] = "6da4295c827eb14f5a2734b0f38033639e5f3f141668eba69a0923fc3adaf39e"
