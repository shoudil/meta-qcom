require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "74bc46555034173a4d5282fe96b1e96e0874cfd7f874f4483d431eaa72300345"
