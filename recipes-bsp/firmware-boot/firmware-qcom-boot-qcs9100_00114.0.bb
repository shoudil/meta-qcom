require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "963d54a9e9a3ef29c6933b3d71faa035b72df07cc36f42c14c39ed5f47878026"
