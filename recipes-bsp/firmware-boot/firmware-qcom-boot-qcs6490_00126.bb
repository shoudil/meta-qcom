require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "25b19ccc56d6e4133df15b7b5ac9353357efc66cbf17e9f84d0a459724e0e3e0"
