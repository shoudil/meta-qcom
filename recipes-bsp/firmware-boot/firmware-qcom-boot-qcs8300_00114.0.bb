require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "2067015d9a96d7e009ffec3a42bb7f88a659eb96c6b9e6f9df849af222a8f0e3"
