require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "9693a9d6ceeb8ecd47f6d8f7a4e28180602973d7d47da77673023a6fa7ad5789"
