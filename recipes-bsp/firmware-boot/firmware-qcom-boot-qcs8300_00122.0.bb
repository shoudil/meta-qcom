require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "f14c2f0dc9911f081e90c6be077139e4f29cd70d8b0f0089f4e1b9e592613a06"
