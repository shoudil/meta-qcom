require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "a5cd09352d760699ca79d76b28a20f6519db8d2c3b121074c15235d01f7e3a76"
