require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "c9b0332873feda447b32491dcbbc96255c3cf88da1868d89ac5113b01cb42f75"
