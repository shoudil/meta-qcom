require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "0b2bfc49a1501bdc2985a2d82b2c5395c87d4ca21070686a8da73a03c73e1fdc"
