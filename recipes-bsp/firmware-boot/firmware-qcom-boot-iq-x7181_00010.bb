require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "6bab4c5e33506fb8babc1ad290ac2f6643cb2750286aa9e82c3659381148b9a6"
