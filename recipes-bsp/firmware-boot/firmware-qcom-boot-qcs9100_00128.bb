require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "1d2c6a05abe05af7a2376fd1bd983725661631b43eff188fa227a90042ab99ac"
