require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "bdbc6aa0390f5c78059e0d9f2c70f8bc0695b350d1a8a47d65c9c758847050f2"
