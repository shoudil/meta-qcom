require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "973a3116f77fab22e378848d6e40c48ba20ce4b14e019e44234c844c8bb87838"
