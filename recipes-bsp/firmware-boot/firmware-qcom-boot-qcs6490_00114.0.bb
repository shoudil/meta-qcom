require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "3bfc7748493e4ac8d8ad77db5c132b5301195ce02d377c62171332a81901f552"
