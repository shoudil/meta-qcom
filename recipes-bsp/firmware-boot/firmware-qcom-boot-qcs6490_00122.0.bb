require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "287ac42f1429a36e9867e09cf6a6fd979ebf929e6606ca9308bf15f901d010df"
