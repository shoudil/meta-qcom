require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "df120b750128166c9f8f9ad28c7ecd30d3938c2750a250f2a12362757dc416b0"
