require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "a0fca33863d5a665535717aa943d668d3ffa9e2970bbc10e7e5d04d9269a1b1f"
