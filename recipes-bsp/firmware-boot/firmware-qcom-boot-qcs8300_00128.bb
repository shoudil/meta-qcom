require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "9f32e0c45bcbfe2bf05e540c1be974180e7b4432d9cb20d63c903b5d426cd2ab"
